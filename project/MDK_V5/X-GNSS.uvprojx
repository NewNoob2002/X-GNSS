# Keil uVision project X-GNSS.uvprojx, settings and files
target X-GNSS (6160000::V6.16::ARMCLANG)
  device: -AT32F435RGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: X-GNSS +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F435RGT7,USE_STDPERIPH_DRIVER,ARDUINO=111
  c include: ..\..\user\inc;..\..\user\gui;..\..\platform\f435\cmsis\cm4\device_support;..\..\platform\f435\cmsis\cm4\core_support;..\..\platform\f435\drivers\inc;..\..\platform\f435\mcu;..\..\platform\f435\core;..\..\platform\f435\HAL;..\..\Arduino;..\..\Arduino\libraries\SPI\src;..\..\Arduino\libraries\Wire\src;..\..\libraries\Adafruit_GFX;..\..\libraries\Adafruit_BusIO;..\..\libraries\Adafruit_ST77xx;..\..\libraries\SdFat-2.3.1\src;..\..\libraries\SdFat-2.3.1\src\common;..\..\libraries\SdFat-2.3.1\src\ExFatLib;..\..\libraries\SdFat-2.3.1\src\FatLib;..\..\libraries\SdFat-2.3.1\src\FsLib;..\..\libraries\SdFat-2.3.1\src\iostream;..\..\libraries\SdFat-2.3.1\src\SdCard;..\..\libraries\lvgl;..\..\libraries\lvgl\porting
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../../user/: main.cpp
  group user/src
    ../../user/src/: at32f435_437_int.c at32f435_437_wk_config.c wk_system.c
  group gui
    ../../user/gui/ui/: actions.c anim.c images.c screens.c styles.c ui.c
    ../../user/gui/font/: main_symbol2.c main_symbol32.c symbol_radio.c symbol_satellite48.c
  group platform/cmsis
    ./: startup_at32f435_437.s
    ../../platform/f435/cmsis/cm4/device_support/: system_at32f435_437.c
  group platform/drivers
    ../../platform/f435/drivers/src/: at32f435_437_adc.c at32f435_437_crm.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_edma.c at32f435_437_exint.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c
  group platform/core
    ../../platform/f435/core/adc/: adc.cpp adc_config.cpp
    ../../platform/f435/core/gpio/: gpio.cpp
    ../../platform/f435/core/usart/: usart.cpp usart_config.cpp
  group Arduino
    ../../Arduino/: delay.c itoa.c yield.c abi.cpp Print.cpp Stream.cpp WMath.cpp WString.cpp
    ../../Arduino/variants/at32f403a_xx/: variant.cpp
    ../../Arduino/avr/: dtostrf.c
  group Arduino/libraries
    ../../Arduino/libraries/SPI/src/: SPI.cpp SPI_config.cpp
    ../../Arduino/libraries/Wire/src/: Wire.cpp
  group libraries/Adafruit_GFX
    ../../libraries/Adafruit_BusIO/: Adafruit_BusIO_Register.cpp Adafruit_GenericDevice.cpp Adafruit_I2CDevice.cpp Adafruit_SPIDevice.cpp
    ../../libraries/Adafruit_GFX/: Adafruit_GFX.cpp Adafruit_SPITFT.cpp
    ../../libraries/Adafruit_ST77xx/: Adafruit_ST77xx.cpp Adafruit_ST7789.cpp
  group libraries/SdFat
    ../../libraries/SdFat-2.3.1/src/: FreeStack.cpp
    ../../libraries/SdFat-2.3.1/src/SdCard/: SdCardInfo.cpp
    ../../libraries/SdFat-2.3.1/src/SdCard/SdSpiCard/: SdSpiCard.cpp
    ../../libraries/SdFat-2.3.1/src/common/: FmtNumber.cpp FsCache.cpp FsDateTime.cpp FsStructs.cpp FsUtf.cpp PrintBasic.cpp upcase.cpp FsName.cpp
    ../../libraries/SdFat-2.3.1/src/ExFatLib/: ExFatDbg.cpp ExFatFile.cpp ExFatFilePrint.cpp ExFatFileWrite.cpp ExFatFormatter.cpp ExFatName.cpp ExFatPartition.cpp ExFatVolume.cpp
    ../../libraries/SdFat-2.3.1/src/FatLib/: FatDbg.cpp FatFile.cpp FatFileLFN.cpp FatFilePrint.cpp FatFileSFN.cpp FatFormatter.cpp FatName.cpp FatPartition.cpp FatVolume.cpp
    ../../libraries/SdFat-2.3.1/src/FsLib/: FsFile.cpp FsNew.cpp FsVolume.cpp
    ../../libraries/SdFat-2.3.1/src/iostream/: istream.cpp ostream.cpp StdioStream.cpp StreamBaseClass.cpp
    ../../libraries/SdFat-2.3.1/src/SdCard/SdSpiCard/SpiDriver/: SdSpiChipSelect.cpp
  group libraries/lvgl/config
    ../../libraries/lvgl/: lv_conf.h
  group libraries/lvgl/src
    ../../libraries/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../libraries/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../libraries/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../libraries/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../libraries/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../libraries/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../libraries/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../libraries/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../libraries/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../libraries/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../libraries/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../libraries/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../libraries/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../libraries/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../libraries/lvgl/src/extra/widgets/led/: lv_led.c
    ../../libraries/lvgl/src/extra/widgets/list/: lv_list.c
    ../../libraries/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../libraries/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../libraries/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../libraries/lvgl/src/extra/widgets/span/: lv_span.c
    ../../libraries/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../libraries/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../libraries/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../libraries/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../libraries/lvgl/src/extra/widgets/win/: lv_win.c
    ../../libraries/lvgl/src/extra/: lv_extra.c
    ../../libraries/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../libraries/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../libraries/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../libraries/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group libraries/lvgl/port
    ../../libraries/lvgl/porting/: lv_port_disp.cpp
  group libraries/lvgl/demos
    ../../libraries/lvgl/demos/widgets/: lv_demo_widgets.c
    ../../libraries/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group HAL
    ../../platform/f435/HAL/: HAL.cpp HAL_Display.cpp
